# Repository xfa273/NucleoMouse2023

File README.md:

WMMCで2023年頃から使っている標準機体のソフトです．古いtoolchainでしかビルドできない問題を修正してあるはずです．

## EAGLE design hardware/cad/Nucleo_Mouse_v2.brd

File hardware/README.md:

# Hardware Data Layout

このディレクトリは `NucleoMouse2023` の回路・基板製造データを保管する場所です。

- `cad/`: CAD元データ（`.sch`, `.brd`, PDF など）
- `gerber/`: 発注用ガーバー出力（ZIP）

## CubeIDE運用との関係

- `CubeIDE` のビルド対象は `.cproject` の `sourceEntries` で `Core/` と `Drivers/` のみです。
- そのため `hardware/` 配下はビルド・リンク対象になりません。
- プロジェクト直下の日本語フォルダ名を避け、OS差異（特に Windows の文字化け/正規化差）を減らすために英数字パスへ整理しています。

Parts:
C1, C2: 25V470uF; E5-10,5
C3: 0.1uF; C050-024X044
C4, C5: 10uF; C050-024X044
D1: DIODE300MIL; D-7.5
DRIVER_L: SLA7078VANILLA; SLA7078_VANILLA
DRIVER_R: SLA7078VANILLA; SLA7078_VANILLA
F1: RGEF300
LED1, LED2, LED3, LED4-1, LED4-2: LED3MM
LED_BATT: LED3MM
MOTOR_L: CON6
MOTOR_R: CON6
NUCLEO32-F303K8: NUCLEO-F303K8; DIPS1524W66P254L5029H1500Q30N
R0: 0; 0204/7
R1: 33k; 0204/7
R2, R12: 10k; 0204/7
R3, R4, R5, R6, R7, R8: 1.0k; 0204/7
R9, R10: 100; 0204/7
R11: 3.3k; 0204/7
R-78E5.0-0.5: R-78E5.0-0.5; CONV_R-78E5.0-0.5
SW1, SW2, SW3: TACT_SW; AKI_TACT
SW-P: TL32PO; TL3XPO
SW_RESET: TACT_SW; AKI_TACT
U$1, U$2, U$3, U$4, U$5, U$6, U$7, U$8: PAD-SQUARE-4; PAD-SQUARE-2.54
U$9: XT30UPB-M
VR1: 500; B25P

Connections:
+3.3V: DRIVER_L.M1, DRIVER_L.M2, DRIVER_L.VDD, DRIVER_R.M1, DRIVER_R.M2, DRIVER_R.VDD, NUCLEO32-F303K8.17 (+3V3), R9.1, R11.1, R12.1, U$1.2-1 (2), U$1.2-2 (2), U$2.2-1 (2), U$2.2-2 (2), U$3.2-1 (2), U$3.2-2 (2), U$4.2-1 (2), U$4.2-2 (2)
+5V: C5.1, NUCLEO32-F303K8.27 (+5V), R8.2, R-78E5.0-0.5.3 (+VOUT)
+12V: C1.+, C2.+, C4.1, DRIVER_L.VBB, DRIVER_R.VBB, MOTOR_L.P$2 (2), MOTOR_L.P$5 (5), MOTOR_R.P$2 (2), MOTOR_R.P$5 (5), R1.2, R-78E5.0-0.5.1 (+VIN), SW-P.2
-SB16-PB6: NUCLEO32-F303K8.24 (PA6(A5))
-SB18-PB7: NUCLEO32-F303K8.23 (PA5(A4))
CLOCK_L: DRIVER_L.CLOCK, NUCLEO32-F303K8.14 (PB5(D11))
CLOCK_R: DRIVER_R.CLOCK, NUCLEO32-F303K8.15 (PB4(D12))
CW/CCW_L: DRIVER_L.CW/CCW, NUCLEO32-F303K8.16 (PB3(D13))
CW/CCW_R: DRIVER_R.CW/CCW, NUCLEO32-F303K8.8 (PB6(D5))
GND: C3.2, C4.2, C5.2, DRIVER_L.RESET, DRIVER_L.SYNC, DRIVER_R.RESET, DRIVER_R.SYNC, LED1.K (C), LED2.K (C), LED3.K (C), LED4-1.K (C), LED4-2.K (C), LED_BATT.K (C), NUCLEO32-F303K8.4 (GND), NUCLEO32-F303K8.29 (GND), R0.2, R2.1, R10.2, R-78E5.0-0.5.2 (GND), SW1.1-B, SW1.2-B, SW2.1-B, SW2.2-B, SW3.1-B, SW3.2-B, SW_RESET.1-B, SW_RESET.2-B, U$1.1-1 (1), U$1.1-2 (1), U$2.1-1 (1), U$2.1-2 (1), U$3.1-1 (1), U$3.1-2 (1), U$4.1-1 (1), U$4.1-2 (1)
GND2: C1.-, C2.-, D1.A, DRIVER_L.GND, DRIVER_R.GND, R0.1
IR_FRONT: NUCLEO32-F303K8.2 (PA10(D0)), U$1.3-1 (3), U$1.3-2 (3), U$2.3-1 (3), U$2.3-2 (3)
IR_SIDE: NUCLEO32-F303K8.21 (PA3(A2)), U$3.3-1 (3), U$3.3-2 (3), U$4.3-1 (3), U$4.3-2 (3)
LED1: NUCLEO32-F303K8.10 (PF0(D7)), R3.1
LED2: NUCLEO32-F303K8.5 (PA12(D2)), R4.1
LED3: NUCLEO32-F303K8.6 (PB0(D3)), R5.1
LED4: NUCLEO32-F303K8.1 (PA9(D1)), R6.1, R7.1
M3: DRIVER_L.M3, DRIVER_R.M3, NUCLEO32-F303K8.7 (PB7(D4)), R12.2
unnamed: F1.1, U$9.P$1 (+)
unnamed: LED4-1.A, R6.2
unnamed: LED4-2.A, R7.2
unnamed: LED3.A, R3.2
unnamed: LED2.A, R4.2
unnamed: LED1.A, R5.2
unnamed: LED_BATT.A, R8.1
unnamed: D1.C, U$9.P$2 (-)
unnamed: F1.2, SW-P.3 (S)
unnamed: R10.1, VR1.A
unnamed: R11.2, VR1.E
OUTA/_L: DRIVER_L.OUTA/, DRIVER_L.OUTA/_2, MOTOR_L.P$6 (6)
OUTA/_R: DRIVER_R.OUTA/, DRIVER_R.OUTA/_2, MOTOR_R.P$6 (6)
OUTA_L: DRIVER_L.OUTA, DRIVER_L.OUTA_2, MOTOR_L.P$4 (4)
OUTA_R: DRIVER_R.OUTA, DRIVER_R.OUTA_2, MOTOR_R.P$4 (4)
OUTB/_L: DRIVER_L.OUTB/, DRIVER_L.OUTB/_2, MOTOR_L.P$1 (1)
OUTB/_R: DRIVER_R.OUTB/, DRIVER_R.OUTB/_2, MOTOR_R.P$1 (1)
OUTB_L: DRIVER_L.OUTB, DRIVER_L.OUTB_2, MOTOR_L.P$3 (3)
OUTB_R: DRIVER_R.OUTB, DRIVER_R.OUTB_2, MOTOR_R.P$3 (3)
RESET: NUCLEO32-F303K8.3 (!RST), NUCLEO32-F303K8.28 (!RST), R9.2, SW_RESET.1-A, SW_RESET.2-A
SENSOR_FL: NUCLEO32-F303K8.25 (PA7(A6)), U$2.4-1 (4), U$2.4-2 (4)
SENSOR_FR: NUCLEO32-F303K8.20 (PA1(A1)), U$1.4-1 (4), U$1.4-2 (4)
SENSOR_L: NUCLEO32-F303K8.19 (PA0(A0)), U$4.4-1 (4), U$4.4-2 (4)
SENSOR_R: NUCLEO32-F303K8.22 (PA4(A3)), U$3.4-1 (4), U$3.4-2 (4)
SW1: NUCLEO32-F303K8.12 (PA8(D9)), SW1.1-A, SW1.2-A
SW2: NUCLEO32-F303K8.13 (PA11(D10)), SW2.1-A, SW2.2-A
SW3: NUCLEO32-F303K8.11 (PF1(D8)), SW3.1-A, SW3.2-A
USART2_DEFAULT: NUCLEO32-F303K8.26 (PA2(A7))
VOL_CHECK: NUCLEO32-F303K8.9 (PB1(D6)), R1.1, R2.2
VREF: C3.1, DRIVER_L.REF/SLEEP1, DRIVER_R.REF/SLEEP1, VR1.S

Notes on the sheet:
スイッチ
LED
コネクタtoセンサー
モータードライバー
Nucleoボード

Board: 2 copper layers, 80.0 x 90.0 mm, 47 parts (8 on the bottom side), 45 nets.

## EAGLE design hardware/cad/Nucleo_Mouse_SensorBoard_v2.brd

Parts:
2N2: 2N7000
C1: 0.1u; C2.5-3
C2: 16V 100u; E2-4
LED3: emit; LED5MM
R1: 5.6k; 0204/7
R2: 3.9k; 0204/7
R3: 10k; 0204/7
R4: 47; 0204/7
SENS_1, SENS_2: TP-1X4; 1X04
T3: L-51ROPT1D1

Connections:
GND: 2N2.S, C2.-, R1.2, R2.2, R3.2, SENS_1.1, SENS_2.1
IR_R: 2N2.G, R3.1, SENS_1.3, SENS_2.3
unnamed: C2.+, LED3.A, R4.2
unnamed: 2N2.D, LED3.K (C)
unnamed: C1.1, R1.1, T3.EMITTER (E)
SENSOR_R: C1.2, R2.1, SENS_1.4, SENS_2.4
VCC: R4.1, SENS_1.2, SENS_2.2, T3.COLLECTOR (C)

Notes on the sheet:
右上部

Board: 2 copper layers, 20.0 x 35.0 mm, 11 parts (1 on the bottom side), 7 nets.

## Code that names these connections

File NucleoMouse2023.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=SENSOR_L
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=SENSOR_FR
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=IR_FRONT
PA10.Signal=GPIO_Output
PA11.GPIOParameters=GPIO_PuPd,GPIO_Label
PA11.GPIO_Label=SW2
PA11.GPIO_PuPd=GPIO_PULLUP
PA11.Signal=GPIO_Input
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=LED2
PA12.Signal=GPIO_Output
PA13.GPIOParameters=GPIO_Label
PA13.GPIO_Label=SWDIO
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.GPIOParameters=GPIO_Label
PA14.GPIO_Label=SWCLK
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=VCP_RX
PA15.Mode=Asynchronous
PA15.Signal=USART2_RX
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=VCP_TX
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=IR_SIDE
PA3.Signal=GPIO_Output
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=SENSOR_R
PA4.Mode=IN1-Single-Ended
PA4.Signal=ADC2_IN1
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=M3_2
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=CW/CCW_R_2
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=SENSOR_FL
PA7.Mode=IN4-Single-Ended
PA7.Signal=ADC2_IN4
PA8.GPIOParameters=GPIO_PuPd,GPIO_Label
PA8.GPIO_Label=SW1
PA8.GPIO_PuPd=GPIO_PULLUP
PA8.Signal=GPIO_Input
PA9.GPIOParameters=GPIO_PuPd,GPIO_Label
PA9.GPIO_Label=LED4
PA9.GPIO_PuPd=GPIO_NOPULL
PA9.Signal=GPIO_Output
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=LED3
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=VOL_CHECK
PB1.Mode=IN12-Single-Ended
PB1.Signal=ADC1_IN12
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=CW/CCW_L
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=CLOCK_R
PB4.Signal=S_TIM16_CH1
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=CLOCK_L
PB5.Signal=S_TIM17_CH1
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=CW/CCW_R
PB6.Signal=GPIO_Output
PB7.GPIOParameters=GPIO_PuPd,GPIO_Label
PB7.GPIO_Label=M3
PB7.GPIO_PuPd=GPIO_NOPULL
PB7.Signal=GPIO_Output
PF0\ /\ OSC_IN.GPIOParameters=GPIO_Label
PF0\ /\ OSC_IN.GPIO_Label=LED1
PF0\ /\ OSC_IN.Signal=GPIO_Output
PF1\ /\ OSC_OUT.GPIOParameters=GPIO_PuPd,GPIO_Label
PF1\ /\ OSC_OUT.GPIO_Label=SW3
PF1\ /\ OSC_OUT.GPIO_PuPd=GPIO_PULLUP
PF1\ /\ OSC_OUT.Signal=GPIO_Input
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK
board=NUCLEO-F303K8
boardIOC=true

## Commit log

2026-04-15 chore: make NucleoMouse2023 portable for CubeIDE sharing
2026-04-15 docs: add macOS and Windows terminal workflow guide
2026-04-15 chore: organize hardware CAD and gerber data for cross-platform import
2026-04-15 chore: normalize hardware file permissions
